# Keil uVision project OV2640.uvprojx, settings and files
target OV2640 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OV2640 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\DCMI;..\HARDWARE\OV2640;..\HARDWARE\TIMER;..\HARDWARE\USART2;..\FWLIB\inc;..\USMART;..\HARDWARE\STMFLASH;..\HARDWARE\W25QXX;..\HARDWARE\SPI;..\HARDWARE\SDIO;..\FATFS\exfuns;..\FATFS\src;..\MALLOC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/OV2640/: ov2640.c sccb.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_sdio.c
  group MSMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: readme.txt
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group MALLOC
    ../MALLOC/: malloc.c
